#ifndef HAN2_INCLUDE_TEST_KAMSTRUP_NVE_H
#define HAN2_INCLUDE_TEST_KAMSTRUP_NVE_H

namespace han {
namespace test {

class KamstrupNveReplayProfile {
 public:
  KamstrupNveReplayProfile() {
    resetFrames();
    replay_.configure(
      {list1_, sizeof(list1_), HanListType::List1},
      {list2_, sizeof(list2_), HanListType::List2},
      5000,
      20000
    );
  }

  void step(HanReader& reader, unsigned long now_ms, bool dynamic = false) {
    if (dynamic && (last_dynamic_ms_ == 0 || (now_ms - last_dynamic_ms_) >= 5000)) {
      last_dynamic_ms_ = now_ms;
      tick_++;
      resetFrames();
      applyDynamicValues(list1_, sizeof(list1_), false);
      applyDynamicValues(list2_, sizeof(list2_), true);
    }
    replay_.step(reader, now_ms);
  }

 private:
  void resetFrames() {
    memcpy(list1_, kList1Frame, sizeof(list1_));
    memcpy(list2_, kList2Frame, sizeof(list2_));
  }

  static bool findObis(const uint8_t* frame, size_t frameLen,
                       uint8_t a, uint8_t b, uint8_t c, uint8_t d, uint8_t e, uint8_t f,
                       size_t& valueIndex, uint8_t& type) {
    for (size_t i = 0; i + 14 < frameLen; ++i) {
      if (frame[i] != 0x09 || frame[i + 1] != 0x06) continue;
      if (frame[i + 2] != a || frame[i + 3] != b || frame[i + 4] != c ||
          frame[i + 5] != d || frame[i + 6] != e || frame[i + 7] != f) continue;
      type = frame[i + 8];
      valueIndex = i + 9;
      return true;
    }
    return false;
  }

  static void writeBe32(uint8_t* dst, uint32_t value) {
    dst[0] = (uint8_t)((value >> 24) & 0xFF);
    dst[1] = (uint8_t)((value >> 16) & 0xFF);
    dst[2] = (uint8_t)((value >> 8) & 0xFF);
    dst[3] = (uint8_t)(value & 0xFF);
  }

  static void writeBe16(uint8_t* dst, uint16_t value) {
    dst[0] = (uint8_t)((value >> 8) & 0xFF);
    dst[1] = (uint8_t)(value & 0xFF);
  }

  static void patchU32(uint8_t* frame, size_t frameLen,
                       uint8_t a, uint8_t b, uint8_t c, uint8_t d, uint8_t e, uint8_t f,
                       uint32_t value) {
    size_t valueIndex = 0;
    uint8_t type = 0;
    if (!findObis(frame, frameLen, a, b, c, d, e, f, valueIndex, type) || type != 0x06) return;
    writeBe32(&frame[valueIndex], value);
  }

  static void patchU16(uint8_t* frame, size_t frameLen,
                       uint8_t a, uint8_t b, uint8_t c, uint8_t d, uint8_t e, uint8_t f,
                       uint16_t value) {
    size_t valueIndex = 0;
    uint8_t type = 0;
    if (!findObis(frame, frameLen, a, b, c, d, e, f, valueIndex, type) || type != 0x12) return;
    writeBe16(&frame[valueIndex], value);
  }

  static void patchTimestamp(uint8_t* frame, size_t frameLen, uint32_t secondsSinceStart) {
    for (size_t i = 0; i + 12 < frameLen; ++i) {
      if (frame[i] != 0x0C) continue;
      frame[i + 8] = (uint8_t)(secondsSinceStart % 60U);
      return;
    }
  }

  void applyDynamicValues(uint8_t* frame, size_t frameLen, bool includeTotals) {
    const uint16_t u1 = (uint16_t)(230 + random(0, 11));
    const uint16_t u2 = (uint16_t)(230 + random(0, 11));
    const uint16_t u3 = (uint16_t)(230 + random(0, 11));
    const float i1a = (float)random(0, 1601) / 100.0f;
    const float i2a = (float)random(0, 1601) / 100.0f;
    const float i3a = (float)random(0, 1601) / 100.0f;
    const uint32_t i1 = (uint32_t)lroundf(i1a * 100.0f);
    const uint32_t i2 = (uint32_t)lroundf(i2a * 100.0f);
    const uint32_t i3 = (uint32_t)lroundf(i3a * 100.0f);
    const uint32_t pTotal = (uint32_t)lroundf((u1 * i1a) + (u2 * i2a) + (u3 * i3a));

    patchTimestamp(frame, frameLen, tick_ * 5U);
    patchU32(frame, frameLen, 0x01,0x01,0x01,0x07,0x00,0xFF, pTotal);
    patchU32(frame, frameLen, 0x01,0x01,0x02,0x07,0x00,0xFF, 0);
    patchU32(frame, frameLen, 0x01,0x01,0x1F,0x07,0x00,0xFF, i1);
    patchU32(frame, frameLen, 0x01,0x01,0x33,0x07,0x00,0xFF, i2);
    patchU32(frame, frameLen, 0x01,0x01,0x47,0x07,0x00,0xFF, i3);
    patchU16(frame, frameLen, 0x01,0x01,0x20,0x07,0x00,0xFF, u1);
    patchU16(frame, frameLen, 0x01,0x01,0x34,0x07,0x00,0xFF, u2);
    patchU16(frame, frameLen, 0x01,0x01,0x48,0x07,0x00,0xFF, u3);

    if (!includeTotals) return;
    patchU32(frame, frameLen, 0x01,0x01,0x01,0x08,0x00,0xFF, 357614U + tick_ * 13U);
    patchU32(frame, frameLen, 0x01,0x01,0x02,0x08,0x00,0xFF, 42062U + tick_ * 2U);
  }

  inline static const uint8_t kList2Frame[] = {
    0x7E,0xA1,0x2C,0x2B,0x21,0x13,0xFC,0x04,0xE6,0xE7,0x00,0x0F,0x00,0x00,0x00,0x00,
    0x0C,0x07,0xEA,0x03,0x04,0x03,0x11,0x00,0x37,0xFF,0x80,0x00,0x00,0x02,0x23,0x0A,
    0x0E,0x4B,0x61,0x6D,0x73,0x74,0x72,0x75,0x70,0x5F,0x56,0x30,0x30,0x30,0x31,0x09,
    0x06,0x01,0x01,0x00,0x00,0x05,0xFF,0x0A,0x10,0x35,0x37,0x30,0x36,0x35,0x36,0x37,
    0x33,0x35,0x32,0x38,0x35,0x35,0x39,0x30,0x37,0x09,0x06,0x01,0x01,0x60,0x01,0x01,
    0xFF,0x0A,0x12,0x36,0x38,0x34,0x31,0x31,0x33,0x38,0x41,0x4E,0x32,0x34,0x35,0x31,
    0x30,0x31,0x30,0x39,0x32,0x09,0x06,0x01,0x01,0x01,0x07,0x00,0xFF,0x06,0x00,0x00,
    0x00,0x00,0x09,0x06,0x01,0x01,0x02,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,
    0x06,0x01,0x01,0x03,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,0x06,0x01,0x01,
    0x04,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,0x06,0x01,0x01,0x1F,0x07,0x00,
    0xFF,0x06,0x00,0x00,0x02,0x08,0x09,0x06,0x01,0x01,0x33,0x07,0x00,0xFF,0x06,0x00,
    0x00,0x01,0x54,0x09,0x06,0x01,0x01,0x47,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0xB4,
    0x09,0x06,0x01,0x01,0x20,0x07,0x00,0xFF,0x12,0x00,0xE6,0x09,0x06,0x01,0x01,0x34,
    0x07,0x00,0xFF,0x12,0x00,0xE4,0x09,0x06,0x01,0x01,0x48,0x07,0x00,0xFF,0x12,0x00,
    0xE8,0x09,0x06,0x00,0x01,0x01,0x00,0x00,0xFF,0x09,0x0C,0x07,0xEA,0x03,0x04,0x03,
    0x11,0x00,0x37,0xFF,0x80,0x00,0x00,0x09,0x06,0x01,0x01,0x01,0x08,0x00,0xFF,0x06,
    0x00,0x05,0x74,0xEE,0x09,0x06,0x01,0x01,0x02,0x08,0x00,0xFF,0x06,0x00,0x00,0x00,
    0x00,0x09,0x06,0x01,0x01,0x03,0x08,0x00,0xFF,0x06,0x00,0x00,0xA4,0x4E,0x09,0x06,
    0x01,0x01,0x04,0x08,0x00,0xFF,0x06,0x00,0x00,0x01,0x26,0x09
  };

  inline static const uint8_t kList1Frame[] = {
    0x7E,0xA0,0xE2,0x2B,0x21,0x13,0x23,0x9A,0xE6,0xE7,0x00,0x0F,0x00,0x00,0x00,0x00,
    0x0C,0x07,0xEA,0x03,0x04,0x03,0x11,0x01,0x00,0xFF,0x80,0x00,0x00,0x02,0x19,0x0A,
    0x0E,0x4B,0x61,0x6D,0x73,0x74,0x72,0x75,0x70,0x5F,0x56,0x30,0x30,0x30,0x31,0x09,
    0x06,0x01,0x01,0x00,0x00,0x05,0xFF,0x0A,0x10,0x35,0x37,0x30,0x36,0x35,0x36,0x37,
    0x33,0x35,0x32,0x38,0x35,0x35,0x39,0x30,0x37,0x09,0x06,0x01,0x01,0x60,0x01,0x01,
    0xFF,0x0A,0x12,0x36,0x38,0x34,0x31,0x31,0x33,0x38,0x41,0x4E,0x32,0x34,0x35,0x31,
    0x30,0x31,0x30,0x39,0x32,0x09,0x06,0x01,0x01,0x01,0x07,0x00,0xFF,0x06,0x00,0x00,
    0x00,0x00,0x09,0x06,0x01,0x01,0x02,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,
    0x06,0x01,0x01,0x03,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,0x06,0x01,0x01,
    0x04,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0x00,0x09,0x06,0x01,0x01,0x1F,0x07,0x00,
    0xFF,0x06,0x00,0x00,0x02,0x08,0x09,0x06,0x01,0x01,0x33,0x07,0x00,0xFF,0x06,0x00,
    0x00,0x01,0x54,0x09,0x06,0x01,0x01,0x47,0x07,0x00,0xFF,0x06,0x00,0x00,0x00,0xB4,
    0x09,0x06,0x01,0x01,0x20,0x07,0x00,0xFF,0x12,0x00,0xE6,0x09,0x06,0x01,0x01,0x34,
    0x07,0x00,0xFF,0x12,0x00,0xE4,0x09,0x06,0x01,0x01,0x48,0x07,0x00,0xFF,0x12,0x00,
    0xE8,0x69,0x1E,0x7E
  };

  uint8_t list1_[sizeof(kList1Frame)];
  uint8_t list2_[sizeof(kList2Frame)];
  HanReplayDriver replay_;
  unsigned long last_dynamic_ms_ = 0;
  uint32_t tick_ = 0;
};

}  // namespace test
}  // namespace han

#endif
